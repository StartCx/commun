# Keil uVision project project.uvprojx, settings and files
target Pro (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: uart_to_USB_ascii +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\HARDWARE;..\Libraries\STM32F10x_StdPeriph_Driver;..\Libraries\STM32_USB-FS-Device_Driver;..\SYSTEM;..\User;..\bsp;..\support;..\Device;..\support\I2C;..\support\SPI;..\support\SPI
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group Core
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group DRIVER
    ../Libraries/STM32F10x_StdPeriph_Driver/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Support
    ../support/: core.c queue.c stack.c static_lib.c shell_driver.c shell_task.c simulated_pwm.c gpio_output.c servo_output.c key_input.c encoder_input.c ymodem.c IR_Receiver.c simulated_uart.c
  group bsp
    ../bsp/: usart.c adc.c flash.c timer.c
  group Devices
    ../Device/: dht11.c hc_sr04.c DS18B20.c
  group I2C
    ../support/I2C/: I2C_Config.c I2C_Bitbang.c I2C_Software.c I2C_Hardware.c I2C_StructLib.h
  group SPI
    ../support/SPI/: SPI_Config.c SPI_Bitbang.c SPI_Software.c SPI_Hardware.c SPI_StructLib.h
